# Keil uVision project template.uvproj, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: template +hex
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=1
  c include: C:\Keil_v5\ARM\RV31\INC\ST\STM32F10x;C:\Keil_v5\ARM\RV31\LIB\ST
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group init
    ./: FS_CM3.lib STM32_Init.c STM32_Init.h STM32F10x.s STM32F10xR.LIB
  group main
    ./: main.c
  group serial
    ./serial/: serial.c serial.h
  group delay
    ./delay/: delay.c delay.h
  group CRC
    ./CRC/: lib_crc.c lib_crc.h
